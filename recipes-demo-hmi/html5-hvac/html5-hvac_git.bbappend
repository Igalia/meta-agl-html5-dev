SRC_URI = "git://github.com/AGL-web-applications/hvac.git;protocol=https;branch=WIP/agl-compositor"
SRCREV = "ca60d367a6016b8cd9af6b73b1d24881980f4592"
