SRC_URI = "git://github.com/AGL-web-applications/launcher.git;protocol=https;branch=WIP/agl-compositor"
SRCREV = "f0422c17371cc5350aa42f6a8b61e0703a35a5d5"
