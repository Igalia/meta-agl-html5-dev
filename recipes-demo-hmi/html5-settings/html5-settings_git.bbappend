SRC_URI = "git://github.com/AGL-web-applications/settings.git;protocol=https;branch=WIP/agl-compositor"
SRCREV = "627e41507c013614e436d0f415e91f18385f2810"
