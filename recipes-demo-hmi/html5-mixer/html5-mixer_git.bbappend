SRC_URI = "git://github.com/AGL-web-applications/mixer.git;protocol=https;branch=WIP/agl-compositor"
SRCREV = "6b3b014f7ec31a2d017e1eab1e02415dcaa45c39"
