SRC_URI = "git://github.com/AGL-web-applications/dashboard.git;protocol=https;branch=WIP/agl-compositor"
SRCREV = "72912c13081dc48ccb16725c6e14ba1eb453ac35"
