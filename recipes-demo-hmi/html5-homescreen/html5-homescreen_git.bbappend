SRC_URI = "git://github.com/AGL-web-applications/homescreen.git;protocol=https;branch=WIP/agl-compositor"
SRCREV = "e62789889bb2d21b199026fa9f9baf4eddff6911"
