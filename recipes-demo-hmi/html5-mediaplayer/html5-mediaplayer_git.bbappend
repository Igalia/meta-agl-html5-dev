SRC_URI = "git://github.com/AGL-web-applications/mediaplayer.git;protocol=https;branch=WIP/agl-compositor"
SRCREV = "3cf155d99a93d6dda5e2d0a4f6b35ef626402d04"
