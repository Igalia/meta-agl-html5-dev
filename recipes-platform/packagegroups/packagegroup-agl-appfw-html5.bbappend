RDEPENDS_${PN}_remove = "chromium-browser-service"
