SRC_URI = "git://gerrit.automotivelinux.org/gerrit/src/agl-compositor.git;protocol=https;branch=master"
SRCREV = "5fe16df2348396c87ab24ef5e2a5e6ceaf2eb4c6"
