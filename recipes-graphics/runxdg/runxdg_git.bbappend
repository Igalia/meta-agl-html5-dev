SRC_URI = "git://github.com/Igalia/xdg-launcher.git;protocol=https;branch=WIP/agl-compositor"
SRCREV  = "0cf3011dba29c298fee8008a02179eb6991c4a2c"
